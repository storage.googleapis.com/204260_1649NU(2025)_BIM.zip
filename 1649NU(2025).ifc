Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 1649NU(2025).ifc
Time: 2025-05-20T22:44:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_342083_4
InPort_342083_5

# IfcFlowController: 1649NU(2025):1649NU Bath and shower faucet with shower set, 1649NU(2025):1649NU Bath and shower faucet with shower set:342083
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 1649NU(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_10; Uniclass2015Description: Bath thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_10; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1111; ETIM Class Number: EC010862 Bath mixing tap; Noise Class: II (ISO 3822); URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1649NU; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1649NU
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Eccentric coupling(s); Connection Size: G1/2; Diverter: Turn operated diverter;Integrated into flow control handle; Eco Flow At 300kPa: 0.16 dm3/s; Flow Rate At 300kPa: 0.34 dm3/s; Hand Shower Size: Ø 90 mm; Installation Type: Wall mounted; Installation Width: 150 ± 15 mm; Lever Handle: Temperature control handle;Flow control handle;Eco feature for water flow;Safety feature for water temperature; Max. Hot Water Supply: 65 C; Mechanical Parts: Thermostatic cartridge for automatic temperature control;Litter filter(s);Ceramic head part for flow control; Shower Parts: Hand shower;Shower rail;Shower hose (1500 mm);Eco flow control; Shower Spray: Normal - Even and soft water stream;Refreshing - Strong water stream, activates and refreshes body;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Spout Projection: 160 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature: Thermostatic temperature control; Temperature Adjustments: The housing of the fittings conducts minimal heat;Safety stop against scalding at 38°C; Working Pressure: 100 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - FaucetNominalDepth: 175.5 mm; FaucetNominalHeight: 78.8525 mm; FaucetNominalWidth: 290 mm; HandShowerNominalDepth: 127.013 mm; HandShowerNominalHeight: 700 mm; HandShowerNominalWidth: 141.681 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/1649NU; Catalog Drawing URL: http://static.oras.com/catdrw/1649NU; Category B2C: Bathtub & Shower; Dimension Drawing URL: http://static.oras.com/dimdrw/1649NU; FDV Document URL: http://www.oras.com/datasheet/1649NU/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1649NU; Group: BathAndShowerFaucetsWithShowerSet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1649NU; Interactive AR View URL: https://static.oras.com/AR/1649NU; Long Marketing: Introducing this Oras Linea thermostat for bath and shower with shower set - a timeless choice for every modern bathroom. Featuring a sleek chrome finish and wall-mounted installation type, this faucet set not only comes with a universal design but also offers outstanding price-performance ratio. The temperature and flow control handle allow for easy adjustments, while the eco and safety features ensure efficiency and safety. Enjoy a variety of shower spray types with the 3-spray functions, complete with a hand shower, shower rail and shower hose. Upgrade your shower experience for daily enjoyment in everyday use. 7462U Thermostat for bath and shower 1690N Shower set; Manufacturer: Oras; Market: International;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1649NU; Model: 1649NU Bath and shower faucet with shower set; Name_en: 1649NU Bath and shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1649NU; Product Family: Oras Linea; Product Image URL: http://static.oras.com/image/1649NU; Product URL: http://static.oras.com/1649NU; Technical DataSheet URL: http://www.oras.com/datasheet/1649NU/en; Type Name: 1649NU Bath and shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1649NU(2025); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 1649NU; Name: 1649NU Bath and shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 290x180x80 mm; Shower: 140x130x700 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>, Brass
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 300 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerVisibility: yes; Host: Level : Level 0; Level: Level 0; Offset from Host: 0 mm; ShowerDefaultElevation: 1200 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.297382 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 20 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0166475 m3
Identity Data - Mark: 10
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1649NU(2025); Family and Type: 1649NU(2025): 1649NU Bath and shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1649NU Bath and shower faucet with shower set; Type Id: 342067; WarrantyStartDate: n/a
